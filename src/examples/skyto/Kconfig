## src/examples/skyto/Kconfig
```kconfig
menuconfig EXAMPLES_SKYTO
	bool "skyto"
	default n
	---help---
		Enable support for skyto. for summer school
```
